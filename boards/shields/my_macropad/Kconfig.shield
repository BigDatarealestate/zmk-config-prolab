## boards/shields/my_macropad/Kconfig.shield
```kconfig
config SHIELD_MY_MACROPAD
    def_bool $(shields_list_contains,my_macropad)
    select ZMK_LAYOUT_MAPPING_MY_MACROPAD
```
